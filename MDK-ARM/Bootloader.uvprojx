# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,HAL_RTC_MODULE_ENABLED
  c include: ../Inc;           ../Drivers/STM32F1xx_HAL_Driver/Inc;           ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;           ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;           ../Drivers/CMSIS/Include;           ..\Drivers\serial;           ..\Drivers\stm32bl;           ..\Drivers\parser
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
    ../Drivers/serial/: serial.c
    ../Drivers/stm32bl/: stm32bl.c
    ../Drivers/parser/: parser.c
  group Application/User
    ../Src/: stm32f1xx_it.c gpio.c stm32f1xx_hal_msp.c usart.c main.c dma.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_tim.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c
software components: CMSIS:CORE 4.3.0
